# Keil uVision project MPU6050.uvprojx, settings and files
target MPU6050 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\STM32F10x_FWLib\inc;.\Startup;.\Hardware;.\User;.\Hardware;.\STM32F10x_FWLib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ./Hardware/: KEY.c LED.c delay.c IIC.c
  group Startup
    ./Startup/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
